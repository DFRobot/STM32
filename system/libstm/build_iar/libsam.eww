<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libsam.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_debug_sam3s</name>
      <member>
        <project>libsam</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libarduino</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libsam3s_ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>test</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


