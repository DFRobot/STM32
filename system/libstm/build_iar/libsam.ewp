# IAR project libsam.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__
  ICCARM.CCIncludePath2: ..; ..\include; ..\source\templates
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_sam.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Debug_sam3s (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  ICCARM.CCDefines: sam3s4
  ICCARM.CCIncludePath2: ../
configuration Release_sam3s (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libsam.out
  group (top)
    ../: chip.h
  group cmsis/sam3s/include
    ../cmsis/sam3s/include/: sam3s.h sam3s1a.h sam3s1b.h sam3s1c.h sam3s2a.h sam3s2b.h sam3s2c.h sam3s4a.h sam3s4b.h sam3s4c.h
  group cmsis/sam3s/include/component
    ../cmsis/sam3s/include/component/: acc.h adc.h chipid.h crccu.h dacc.h efc.h gpbr.h hsmci.h matrix.h pdc.h pio.h pmc.h pwm.h rstc.h rtc.h rtt.h smc.h spi.h ssc.h supc.h tc.h twi.h uart.h udp.h usart.h wdt.h
  group cmsis/sam3s/include/instance
    ../cmsis/sam3s/include/instance/: acc.h adc.h chipid.h crccu.h dacc.h efc.h gpbr.h hsmci.h matrix.h pioa.h piob.h pioc.h pmc.h pwm.h rstc.h rtc.h rtt.h smc.h spi.h ssc.h supc.h tc0.h tc1.h twi0.h twi1.h uart0.h uart1.h udp.h usart0.h usart1.h wdt.h
  group cmsis/sam3s/include/pio
    ../cmsis/sam3s/include/pio/: sam3s1a.h sam3s1b.h sam3s1c.h sam3s2a.h sam3s2b.h sam3s2c.h sam3s4a.h sam3s4b.h sam3s4c.h
  group cmsis/sam3s/source/templates
    ../cmsis/sam3s/source/templates/: exceptions.c exceptions.h system_sam3s.c system_sam3s.h
  group cmsis/sam3s/source/templates/iar
    ../cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group cmsis/sam3u/include
    ../cmsis/sam3u/include/: sam3u.h sam3u1c.h sam3u1e.h sam3u2c.h sam3u2e.h sam3u4c.h sam3u4e.h system_sam3u.h
  group cmsis/sam3u/include/component
    ../cmsis/sam3u/include/component/: adc.h adc12b.h chipid.h dmac.h efc.h gpbr.h hsmci.h matrix.h pdc.h pio.h pmc.h pwm.h rstc.h rtc.h rtt.h smc.h spi.h ssc.h supc.h tc.h twi.h uart.h udphs.h usart.h wdt.h
  group cmsis/sam3u/include/instance
    ../cmsis/sam3u/include/instance/: adc.h adc12b.h chipid.h dmac.h efc0.h efc1.h gpbr.h hsmci.h matrix.h pioa.h piob.h pioc.h pmc.h pwm.h rstc.h rtc.h rtt.h smc.h spi.h ssc.h supc.h tc0.h twi0.h twi1.h uart.h udphs.h usart0.h usart1.h usart2.h usart3.h wdt.h
  group cmsis/sam3u/include/pio
    ../cmsis/sam3u/include/pio/: sam3u1c.h sam3u1e.h sam3u2c.h sam3u2e.h sam3u4c.h sam3u4e.h
  group cmsis/sam3u/source/templates
    ../cmsis/sam3u/source/templates/: exceptions.c exceptions.h system_sam3u.c
  group cmsis/sam3u/source/templates/iar
    ../cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group include
    ../include/: adc.h pio.h pio_it.h pmc.h pwmc.h rtc.h rtt.h sam3.h spi.h tc.h timetick.h twi.h usart.h wdt.h
  group source
    ../source/: adc.c pio.c pio_it.c pmc.c pwmc.c rtc.c rtt.c spi.c tc.c timetick.c twi.c usart.c wdt.c
