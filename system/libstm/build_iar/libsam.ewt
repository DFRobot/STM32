<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Debug_sam3s</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release_sam3s</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>cmsis</name>
    <group>
      <name>sam3s</name>
      <group>
        <name>include</name>
        <group>
          <name>component</name>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\acc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\adc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\chipid.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\crccu.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\dacc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\efc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\gpbr.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\hsmci.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\matrix.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\pdc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\pio.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\pmc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\pwm.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\rstc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\rtc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\rtt.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\smc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\spi.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\ssc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\supc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\tc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\twi.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\uart.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\udp.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\usart.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\component\wdt.h</name>
          </file>
        </group>
        <group>
          <name>instance</name>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\acc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\adc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\chipid.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\crccu.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\dacc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\efc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\gpbr.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\hsmci.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\matrix.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\pioa.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\piob.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\pioc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\pmc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\pwm.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\rstc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\rtc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\rtt.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\smc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\spi.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\ssc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\supc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\tc0.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\tc1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\twi0.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\twi1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\uart0.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\uart1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\udp.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\usart0.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\usart1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\instance\wdt.h</name>
          </file>
        </group>
        <group>
          <name>pio</name>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\pio\sam3s1a.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\pio\sam3s1b.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\pio\sam3s1c.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\pio\sam3s2a.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\pio\sam3s2b.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\pio\sam3s2c.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\pio\sam3s4a.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\pio\sam3s4b.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\include\pio\sam3s4c.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s1a.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s1b.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s1c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s2a.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s2b.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s4a.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s4b.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3s\include\sam3s4c.h</name>
        </file>
      </group>
      <group>
        <name>source</name>
        <group>
          <name>templates</name>
          <group>
            <name>iar</name>
            <file>
              <name>$PROJ_DIR$\..\cmsis\sam3s\source\templates\iar\startup_sam3s.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\source\templates\exceptions.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\source\templates\exceptions.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\source\templates\system_sam3s.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3s\source\templates\system_sam3s.h</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>sam3u</name>
      <group>
        <name>include</name>
        <group>
          <name>component</name>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\adc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\adc12b.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\chipid.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\dmac.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\efc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\gpbr.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\hsmci.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\matrix.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\pdc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\pio.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\pmc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\pwm.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\rstc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\rtc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\rtt.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\smc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\spi.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\ssc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\supc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\tc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\twi.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\uart.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\udphs.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\usart.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\component\wdt.h</name>
          </file>
        </group>
        <group>
          <name>instance</name>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\adc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\adc12b.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\chipid.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\dmac.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\efc0.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\efc1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\gpbr.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\hsmci.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\matrix.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\pioa.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\piob.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\pioc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\pmc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\pwm.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\rstc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\rtc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\rtt.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\smc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\spi.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\ssc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\supc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\tc0.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\twi0.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\twi1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\uart.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\udphs.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\usart0.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\usart1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\usart2.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\usart3.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\instance\wdt.h</name>
          </file>
        </group>
        <group>
          <name>pio</name>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\pio\sam3u1c.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\pio\sam3u1e.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\pio\sam3u2c.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\pio\sam3u2e.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\pio\sam3u4c.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\include\pio\sam3u4e.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3u\include\sam3u.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3u\include\sam3u1c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3u\include\sam3u1e.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3u\include\sam3u2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3u\include\sam3u2e.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3u\include\sam3u4c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3u\include\sam3u4e.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\cmsis\sam3u\include\system_sam3u.h</name>
        </file>
      </group>
      <group>
        <name>source</name>
        <group>
          <name>templates</name>
          <group>
            <name>iar</name>
            <file>
              <name>$PROJ_DIR$\..\cmsis\sam3u\source\templates\iar\startup_sam3u.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\source\templates\exceptions.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\source\templates\exceptions.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\cmsis\sam3u\source\templates\system_sam3u.c</name>
          </file>
        </group>
      </group>
    </group>
  </group>
  <group>
    <name>include</name>
    <file>
      <name>$PROJ_DIR$\..\include\adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\pio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\pio_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\pmc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\pwmc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\rtc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\rtt.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\sam3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\tc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\timetick.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\twi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\usart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\wdt.h</name>
    </file>
  </group>
  <group>
    <name>source</name>
    <file>
      <name>$PROJ_DIR$\..\source\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\pio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\pio_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\pmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\pwmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\rtt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\tc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\timetick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\twi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\wdt.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\chip.h</name>
  </file>
</project>


