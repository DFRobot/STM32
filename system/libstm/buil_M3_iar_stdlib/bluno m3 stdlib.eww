<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Bluno M3 stdlib.ewp</path>
  </project>
  <batchBuild/>
</workspace>


