<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\CMSIS\Device\ARM\ARMCM3\Source\Templates\IAR\startup_ARMCM3.s</name>
    </file>
  </group>
  <group>
    <name>source</name>
    <file>
      <name>$PROJ_DIR$\..\source\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\stm32f10x_wwdg.c</name>
    </file>
  </group>
</project>


