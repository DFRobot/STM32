# IAR project Bluno M3 stdlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: D:\Program Files\Arduino\hardware\DFRobot\STM32\system\libstm\include; D:\Program Files\Arduino\hardware\DFRobot\STM32\system\libstm; D:\Program Files\Arduino\hardware\DFRobot\STM32\system\CMSIS\Device\ARM\ARMCM3; D:\Program Files\Arduino\hardware\DFRobot\STM32\system\CMSIS\Device\ST\STM32F10x\Include; D:\Program Files\Arduino\hardware\DFRobot\STM32\system\CMSIS\CMSIS\Include; D:\Program Files\Arduino\hardware\DFRobot\STM32\system\CMSIS\Device\ST
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Bluno M3 stdlib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../CMSIS/Device/ARM/ARMCM3/Source/Templates/IAR/: startup_ARMCM3.s
  group source
    ../source/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
